# Keil uVision project LoRaWAN_4.6_L151.uvprojx, settings and files
target LoRaWAN_4.6_L151 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L151CC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: LoRaWAN_4.6_L151 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L151xC,USE_FULL_ASSERT,SX1276MB1MAS,SOFT_SE,REGION_CN470
  c include: ../Core/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/LoRaWAN/App;../Middlewares/Third_Party/LoRaWAN/Crypto;../Middlewares/Third_Party/LoRaWAN/LmHandler;../Middlewares/Third_Party/LoRaWAN/LmHandler/packages;../Middlewares/Third_Party/LoRaWAN/Mac/region;../Middlewares/Third_Party/LoRaWAN/Mac;../Middlewares/Third_Party/LoRaWAN/System;../Middlewares/Third_Party/LoRaWAN/Target;../Middlewares/Third_Party/LoRaWAN/Utilities;../Middlewares/Third_Party/SubGHz_Phy
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l151xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c rtc.c spi.c usart.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group Middlewares/LoRaWan/App
    ../Middlewares/Third_Party/LoRaWAN/App/: lorawan_app.c
  group Middlewares/LoRaWan/Crypto
    ../Middlewares/Third_Party/LoRaWAN/Crypto/: aes.c cmac.c soft-se.c soft-se-hal.c
  group Middlewares/LoRaWan/LmHandler
    ../Middlewares/Third_Party/LoRaWAN/LmHandler/: LmHandler.c LmHandlerMsgDisplay.c
    ../Middlewares/Third_Party/LoRaWAN/LmHandler/packages/: FragDecoder.c LmhpClockSync.c LmhpCompliance.c LmhpFragmentation.c LmhpRemoteMcastSetup.c
  group Middlewares/LoRaWan/Mac
    ../Middlewares/Third_Party/LoRaWAN/Mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
    ../Middlewares/Third_Party/LoRaWAN/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionBaseUS.c RegionCN470.c RegionCN470A20.c RegionCN470A26.c RegionCN470B20.c RegionCN470B26.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
  group Middlewares/LoRaWan/System
    ../Middlewares/Third_Party/LoRaWAN/System/: delay.c fifo.c nvmm.c systime.c timer.c uart.c
  group Middlewares/LoRaWan/Target
    ../Middlewares/Third_Party/LoRaWAN/Target/: adc-board.c board.c CayenneLpp.c cli.c delay-board.c eeprom-board.c gpio-board.c lpm-board.c NvmDataMgmt.c rtc-board.c spi-board.c sx1276mb1mas-board.c sysIrqHandlers.c uart-board.c
  group Middlewares/LoRaWan/Utilities
    ../Middlewares/Third_Party/LoRaWAN/Utilities/: utilities.c
  group Middlewares/SubGHz_Phy
    ../Middlewares/Third_Party/SubGHz_Phy/: sx1276.c
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
